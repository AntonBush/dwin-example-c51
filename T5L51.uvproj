# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: hex2bin.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\source;.\inc
  group device
    ./src/device/: STARTUP.A51
  group driver
    ./src/driver/: can.c timer.c pio.c dgusvar.c sys.c
  group app
    ./src/app/: canrx.c logic.c main.c ui.c
  group lib
    ./src/lib/: bytevector.c round.c
